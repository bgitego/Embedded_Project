<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Lesson1\project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


